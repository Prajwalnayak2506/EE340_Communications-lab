options:
  parameters:
    author: Prajwal
    generate_options: qt_gui
    id: Task_1b
    output_language: python
    title: Task_1b
  states: {}

blocks:
- name: Av
  id: variable
  parameters:
    value: '1'
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '1e-6'
    step: '1e-4'
    stop: '30e-3'
    value: '1e-6'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4300000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/amanrishalch/Documents/EE340/Lab4/Input.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude/(0.025)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Av
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: tanh
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Differential Output
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Output amplitude
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_transcendental_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
