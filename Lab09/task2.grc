options:
  parameters:
    generate_options: qt_gui
    id: task2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: excess_bw
  id: variable_qtgui_range
  parameters:
    label: excess_bw
    rangeType: int
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: f_off
  id: variable_qtgui_range
  parameters:
    label: f_off
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '3'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 11*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: '8000000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 500000 + f_off
    offset: '0'
    phase: '0'
    samp_rate: '8000000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/priyansh/Desktop/EE340/Lab9/output_2.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/priyansh/Desktop/EE340/Lab9/Original_Text.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0_0_1
  id: blocks_skiphead
  parameters:
    num_items: '7'
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.0002'
    init: '0'
    low: '-0.0002'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0628'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: firdes.root_raised_cosine(gain,32*sps*symb_rate,symb_rate,excess_bw,ntaps)
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200000'
    gain: '2'
    interp: '1'
    samp_rate: '8000000'
    type: interp_fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: sps
    taps: |
      firdes.root_raised_cosine(gain, sps * symb_rate, symb_rate, excess_bw, ntaps)
    type: ccf
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '50000'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget@0
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '400000'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget@1
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: '8000000'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget@2
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: '50000'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget@4
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0_0
  id: qtgui_sink_x
  parameters:
    bw: '400000'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget@3
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0_1
  id: qtgui_sink_x
  parameters:
    bw: '50000'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget@5
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: '50000'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget@6
    type: float
  states: {}
- name: qtgui_tab_widget
  id: qtgui_tab_widget
  parameters:
    label0: Symbols
    label1: RRC_output
    label2: Modulated_signal_with noise
    label3: Demodulated_signal_with f_off
    label4: Match_filter_output
    label5: costas_output
    label6: moving_average_output
    num_tabs: '7'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    type: ccf
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: ccf
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_conjugate_cc_0, '0']
- [blocks_abs_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0_1, '0']
- [blocks_complex_to_real_0, '0', blocks_abs_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_threshold_ff_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_uchar_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_1, '0', rational_resampler_xxx_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_1, '0', blocks_file_sink_0_0_1, '0']
- [blocks_skiphead_0_0_1, '0', blocks_pack_k_bits_bb_0_0_1, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_sink_x_0_1_0_1, '0']
- [digital_diff_decoder_bb_0, '0', blocks_skiphead_0_0_1, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_sink_x_0_1_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
