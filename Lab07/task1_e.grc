options:
  parameters:
    generate_options: qt_gui
    id: TASK1_e
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    label: alpha
    start: '0'
    step: '0.1'
    stop: '3'
    value: '2.5'
  states: {}
- name: b1
  id: variable_qtgui_range
  parameters:
    label: b1
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '-0.5'
  states: {}
- name: b2
  id: variable_qtgui_range
  parameters:
    label: b2
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '0.25'
  states: {}
- name: b3
  id: variable_qtgui_range
  parameters:
    label: b3
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '-0.125'
  states: {}
- name: b4
  id: variable_qtgui_range
  parameters:
    label: b4
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '0.0625'
  states: {}
- name: demod_delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '14'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: noise_amp
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.1'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: variable_constellation
  id: variable_constellation
  parameters:
    const_points: '[1,(0.707+0.707j),1j,(-0.707+0.707j),-1,(-0.707-0.707j),-1j,(0.707-0.707j)]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '40'
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '8'
    type: float
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: float
  states: {}
- name: blocks_delay_1_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: float
  states: {}
- name: blocks_delay_1_1
  id: blocks_delay
  parameters:
    delay: '24'
    type: float
  states: {}
- name: blocks_delay_1_1_0
  id: blocks_delay
  parameters:
    delay: '24'
    type: float
  states: {}
- name: blocks_delay_1_2
  id: blocks_delay
  parameters:
    delay: '32'
    type: float
  states: {}
- name: blocks_delay_1_2_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_delay_1_2_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_delay_1_2_1
  id: blocks_delay
  parameters:
    delay: '32'
    type: float
  states: {}
- name: blocks_delay_1_3
  id: blocks_delay
  parameters:
    delay: '8'
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: demod_delay
    type: float
  states: {}
- name: blocks_delay_2_0
  id: blocks_delay
  parameters:
    delay: demod_delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jatin/Desktop/IITB_Files/EE340/22B3922_LAB07/22B3922_LAB07/Output_1e.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jatin/Desktop/IITB_Files/EE340/22B3922_LAB07/22B3922_LAB07/Original_Text.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: b1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: b2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: b2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: b3
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: b3
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_2
  id: blocks_multiply_const_vxx
  parameters:
    const: b4
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_2_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_2_1
  id: blocks_multiply_const_vxx
  parameters:
    const: b4
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_3
  id: blocks_multiply_const_vxx
  parameters:
    const: b1
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '207'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1,(0.707+0.707j),1j,(-0.707+0.707j),-1,(-0.707-0.707j),-1j,(0.707-0.707j)]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '1'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '1'
    type: fff
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, 0.98]'
    fftaps: '0.001'
    type: ffd
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '1'
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    gain: '1'
    interp: '1'
    samp_rate: '400000'
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    gain: '1'
    interp: '1'
    samp_rate: '400000'
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: qtgui_tab_widget_1@2
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_1@1
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_1@4
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_1@3
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_tab_widget_1
  id: qtgui_tab_widget
  parameters:
    label0: Chunks to symbols output - time
    label1: Chunks to symbols output - constellation
    label2: RRC_output_constellation
    label3: equalizer_output - constellation
    label4: match_filter_output_constellation
    label5: error
    num_tabs: '6'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: qtgui_tab_widget_1@0
    size: '1024'
    srate: symbol_rate
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_1@5
    size: '1024'
    srate: '10000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '3'
    interp: '1'
    ntaps: 11*sps
    samp_rate: sps*symbol_rate
    sym_rate: symbol_rate
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '3'
    ntaps: 11*sps
    samp_rate: sps*symbol_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '3'
    ntaps: 11*sps
    samp_rate: sps*symbol_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '2']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '0']
- [analog_sig_source_x_0_2, '0', blocks_multiply_xx_0_2, '1']
- [analog_sig_source_x_0_2_0, '0', blocks_multiply_xx_0_2_0, '0']
- [blocks_add_const_vxx_0, '0', iir_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', blocks_float_to_complex_1, '1']
- [blocks_add_xx_0, '0', root_raised_cosine_filter_0_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_float_to_complex_1, '0']
- [blocks_add_xx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [blocks_add_xx_1, '0', blocks_add_xx_1_0, '1']
- [blocks_add_xx_1, '0', blocks_delay_0, '0']
- [blocks_add_xx_1_0, '0', blocks_multiply_xx_0_2, '0']
- [blocks_add_xx_1_0, '0', blocks_multiply_xx_0_2_0, '1']
- [blocks_add_xx_2, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_float_1, '0', blocks_multiply_xx_0_1, '1']
- [blocks_complex_to_float_1, '1', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_delay_1_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_delay_1_0_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_delay_1_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_delay_1_1_0, '0', blocks_multiply_const_vxx_1_1_0, '0']
- [blocks_delay_1_2, '0', blocks_multiply_const_vxx_1_2, '0']
- [blocks_delay_1_2_0, '0', blocks_multiply_const_vxx_1_2_0, '0']
- [blocks_delay_1_2_0_0, '0', blocks_multiply_const_vxx_1_2_0_0, '0']
- [blocks_delay_1_2_1, '0', blocks_multiply_const_vxx_1_2_1, '0']
- [blocks_delay_1_3, '0', blocks_multiply_const_vxx_1_3, '0']
- [blocks_delay_2, '0', fir_filter_xxx_0, '0']
- [blocks_delay_2_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_const_sink_x_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_1_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_1_1_0, '0', blocks_add_xx_0_0, '2']
- [blocks_multiply_const_vxx_1_2, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_1_2_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_1_2_0_0, '0', blocks_add_xx_0_0, '4']
- [blocks_multiply_const_vxx_1_2_1, '0', blocks_add_xx_0_0, '3']
- [blocks_multiply_const_vxx_1_3, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_0_1, '0', blocks_add_xx_1, '0']
- [blocks_multiply_xx_0_2, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_2_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_2, '0']
- [blocks_multiply_xx_1_0, '0', blocks_add_xx_2, '1']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_pack_k_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_skiphead_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [fir_filter_xxx_0, '0', blocks_float_to_complex_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_xx_1, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_xx_1, '1']
- [fir_filter_xxx_0_0, '0', blocks_float_to_complex_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_multiply_xx_1_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_multiply_xx_1_0, '1']
- [iir_filter_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_1_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_1, '0']
- [rational_resampler_xxx_1_0, '0', blocks_delay_1_0_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_delay_1_1_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_delay_1_2_0_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_delay_1_2_1, '0']
- [rational_resampler_xxx_1_0, '0', blocks_delay_1_3, '0']
- [rational_resampler_xxx_1_0_0, '0', blocks_delay_1, '0']
- [rational_resampler_xxx_1_0_0, '0', blocks_delay_1_0, '0']
- [rational_resampler_xxx_1_0_0, '0', blocks_delay_1_1, '0']
- [rational_resampler_xxx_1_0_0, '0', blocks_delay_1_2, '0']
- [rational_resampler_xxx_1_0_0, '0', blocks_delay_1_2_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_delay_2, '0']
- [root_raised_cosine_filter_0_0_0, '0', blocks_delay_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
